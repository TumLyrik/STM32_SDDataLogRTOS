# Keil uVision project Project.uvprojx, settings and files
target SDDataLogRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L4R9ZIJx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x000A0000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SDDataLogRTOS +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L4R9xx,USE_HAL_DRIVER,STM32_SENSORTILEBOX
  c misc: --no_conditionalize --diag_suppress 1
  c include: ../Inc;../Patch;../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/SensorTile.box;../../../../../Drivers/BSP/Components/hts221;../../../../../Drivers/BSP/Components/lis2mdl;../../../../../Drivers/BSP/Components/lps22hh;../../../../../Drivers/BSP/Components/lsm6dsox;../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../../../../../Middlewares/Third_Party/FreeRTOS/Source/include;../../../../../Drivers/BSP/Components/stts751;../../../../../Middlewares/Third_Party/FatFs/src;../../../../../Middlewares/Third_Party/FatFs/src/drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  link misc: --diag_suppress=L6329
  group Example/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dsox/: lsm6dsox.c lsm6dsox_reg.c
    ../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group User/SDDataLogRTOS
    ../Src/: stm32l4xx_it.c main.c TargetPlatform.c datalog_application.c sd_diskio_SensorTile.box.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/SensorTile.box
    ../../../../../Drivers/BSP/SensorTile.box/: SensorTile.box.c SensorTile.box_audio.c SensorTile.box_bc.c SensorTile.box_bus.c SensorTile.box_env_sensors.c SensorTile.box_env_sensors_ex.c SensorTile.box_motion_sensors.c SensorTile.box_motion_sensors_ex.c SensorTile.box_sd.c
  group Middlewares/FreeRTOS
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/BSP/STM32L4xx_HAL_Driver
    ../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_usb.c
  group Middlewares/FatFs
    ../../../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
software components: CMSIS:CORE 5.2.0
